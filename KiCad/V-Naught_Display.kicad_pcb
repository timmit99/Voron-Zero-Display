# Repository timmit99/Voron-Zero-Display

File README.md:

# V-Naught_Display
Small Voron Display

Small Formfactor dispaly using  a 0.9" or 1.3" OLED dispalys, with either buttons or click-encoder.

## KiCad design KiCad/V-Naught_Display.kicad_pcb

Parts:
C1, C2: 4.7uF; C_0805_2012Metric; LCSC C1779
C3, C4: 0.1uF; C_0805_2012Metric; LCSC C49678
D1: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J2: I2C Header 1; 1pt3in_OLED
J3: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J5: SWD Header; PinHeader_2x05_P1.27mm_Vertical_SMD
J6: I2C Header 2; PinHeader_1x04_P2.54mm_Vertical
J7: USB_Header; 01x04_unpopulated
R1, R2, R3: 10K; R_0805_2012Metric; LCSC C17414
SW1, SW2, SW3, SW4: SW_SPST; SW_PUSH_6mm_H9.5mm
SW5, SW6: SW_SPST; SW_PUSH_6mm
SW7: Rotary_Encoder_Switch; EN11_Encoder
U1: AP2127K-3.3; SOT-23-5; LCSC C156285
U2: STM32F042F6Px; TSSOP-20_4.4x6.5mm_P0.65mm; LCSC C81000
U3: 74LVC1G17; SOT-353_SC-70-5; LCSC C124293

Connections:
+3V3: C2.1, C3.2, C4.1, J2.2, J4.1, J5.1, J6.1, R1.1, R3.1, U1.5 (VOUT), U2.5 (VDDA), U2.16 (VDD)
BOOT0: J4.2, R2.1, U2.1 (PB8)
Button_Down: SW2.1 (A), SW7.B, U2.10 (PA4)
Button_Left: SW3.1 (A), SW7.A, U2.9 (PA3)
Button_Right: SW4.1 (A), U2.8 (PA2)
Button_Up: SW1.1 (A), SW7.S1, U2.7 (PA1)
D+: J1.3 (D+), J7.3, U2.18 (PA10/PA12)
D-: J1.2 (D-), J7.2, U2.17 (PA9/PA11)
GND: C1.2, C2.2, C3.1, C4.2, D1.3 (VSS), J1.4 (ID), J1.5 (GND), J1.6 (Shield), J2.1, J5.3, J5.5, J6.2, J7.4, R2.2, SW1.2 (B), SW2.2 (B), SW3.2 (B), SW4.2 (B), SW5.2 (B), SW6.1 (A), SW7.C, SW7.S2, U1.2 (GND), U2.15 (VSS), U3.3 (GND)
Kill_Switch: SW6.2 (B), U2.11 (PA5)
NeoPixel: U2.6 (PA0), U3.2
unnamed: D1.4 (DIN), U3.4
SCL: J2.3, J6.3, U2.3 (PF1)
SDA: J2.4, J6.4, U2.2 (PF0)
SWDCLK: J3.2, J5.4, R3.2, U2.20 (PA14)
SWDIO: J3.1, J5.2, U2.19 (PA13)
VBUS: C1.1, D1.1 (VDD), J1.1 (VBUS), J7.1, U1.1 (VIN), U1.3 (EN), U3.5 (VCC)
~Reset: J3.3, J5.10, R1.2, SW5.1 (A), U2.4 (NRST)

Board: 2 copper layers, 80.0 x 35.0 mm, 29 parts (16 on the bottom side), 18 nets.

File Production Files/V-Naught_Display_BOM.csv:

Comment,Designator,Footprint,LCSC, LCSC
"4.7uF","C1,C2","Capacitor_SMD:C_0805_2012Metric","","C1779"
"0.1uF","C4,C3","Capacitor_SMD:C_0805_2012Metric","","C49678"
"WS2812B","D1","LED_SMD:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm",""
"MountingHole","H1,H2,H3,H4","MountingHole:MountingHole_3.2mm_M3",""
"USB_B_Micro","J1","Connector_USB:USB_Micro-B_Molex-105017-0001",""
"I2C Header 1","J2","TRA_KiCad_Footprints:1pt3in_OLED",""
"Conn_01x03","J3","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical",""
"Conn_01x02","J4","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical",""
"SWD Header","J5","Connector_PinHeader_1.27mm:PinHeader_2x05_P1.27mm_Vertical_SMD",""
"I2C Header 2","J6","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical",""
"10K","R2,R1,R3","Resistor_SMD:R_0805_2012Metric","","C17414"
"SW_SPST","SW1,SW2,SW3,SW4","Button_Switch_THT:SW_PUSH_6mm_H9.5mm",""
"SW_SPST","SW5,SW6","Button_Switch_THT:SW_PUSH_6mm",""
"Rotary_Encoder_Switch","SW7","TRA_KiCad_Footprints:EN11 Encoder",""
"AP2127K-3.3","U1","Package_TO_SOT_SMD:SOT-23-5","","C156285"
"STM32F042F6Px","U2","Package_SO:TSSOP-20_4.4x6.5mm_P0.65mm","","C81000"
"74LVC1G17","U3","Package_TO_SOT_SMD:SOT-353_SC-70-5","","C124293"

## Commit log

2020-01-17 Readme
2020-01-17 Initial Commit
    Small STM32 based display using a 1.3" I2C display and 4 buttons.
2020-01-20 Production File updates
    Added a click encoder to the center of the buttons as an additional option for input instead of discrete buttons.
    Klipper Config will follow with pinmaps when the boards arrive.
2020-01-21 Display Step File
    Added display STEP file for case designing
2020-01-24 Second I2C Header
    Added a second I2C header for baords with reversed Vcc and Gnd pins.
    Also added a full SWD header as well
    Updated Production files
2020-02-02 minor changes
    not QUITE sure what the changes are for this, probably jsut some silkscreen changes =P
2020-02-28 Encoder Common pin change from 3v3 to Ground
    Need to change encoder center pin to Ground (from 3V3) to allow for pullups to work for pin change detection.
    Also, adding working configs for both the Encoder and Button options
2020-02-28 Updating of images
2020-04-20 Widen to allow for screw mounting on all 4 sides.
    2 screws were deemed insufficient ... =P
2020-04-20 NO SPACES
2020-04-20 Update of .STEP file for display
